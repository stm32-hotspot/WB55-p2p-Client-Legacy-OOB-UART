<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WB55-p2p-Client-Legacy-OOB-UART.ewp</path>
  </project>
  <batchBuild />
</workspace>
